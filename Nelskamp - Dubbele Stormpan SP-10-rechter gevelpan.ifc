Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: test.ifc
Time: 2011-01-01T11:11:11
Author: Architect
Organization: Building Designer Office
Written by: IFC Engine DLL version 1.03 special version
Made in: example
Authorization: The authorising person

# IfcProject, Default Project
Description: Description of Default Project

# IfcSite, Default Site
Description: Description of Default Site; RefLatitude: 24, 28, 0; RefLongitude: 54, 25, 0; RefElevation: 10 mm

# IfcBuilding, Default Building
Description: Description of Default Building

# IfcBuildingStorey, Default Building Storey
In: Default Building
Description: Description of Default Building Storey; Elevation: 0 mm

# IfcBuildingElementProxy: IFCBUILDINGELEMENTPROXY, keramische rechter gevelpan Nelskamp - Dubbele Stormpan SP-10
In: Default Building Storey
Description: Materiaal; Material: Default Material
BCB_Set_ifcbuildingelementproxy - WUID: AgAAAGZs_wABAAAAYBcCAAVWkAAAzUgAAOMlAACYFgIAmxYCAAAA; Hyperlink: http://bibliotheek.bouwconnect.nl/index.html?WUID=AgAAAGZs_wABAAAAYBcCAAVWkAAAzUgAAOMlAACYFgIAmxYCAAAA; breedte: 200 mm; lengte: 300 mm; merk: Nelskamp; NL-SfB tabel 3: g9; serie: Dubbele Stormpan SP-10; werkende breedte: 140 mm; gewicht per st: 2.5 kg/st; vorstbestendig: yes; soortelijke warmte: 840 j/kg·k; eenheid: st
